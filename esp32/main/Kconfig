## esp32/main/Kconfig
```kconfig
config WIFI_PASS
    string "WiFi password"
    help
        This sets the password for the ESPWay access point.
```
